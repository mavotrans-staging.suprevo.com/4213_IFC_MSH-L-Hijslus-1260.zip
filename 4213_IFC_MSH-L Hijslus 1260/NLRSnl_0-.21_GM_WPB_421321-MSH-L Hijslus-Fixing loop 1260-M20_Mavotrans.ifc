Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2022-10-06T11:01:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.5.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 06 11:01:35 2022 * Host: HPZ2-TPLAT * Database: C:\Users\TESSAP~1\AppData\Local\Temp\{E1317AC3-0E7D-43D7-8F57-78262ED02BB8}\ifc * Database version: 5507 * Database creation date: Thu Oct 06 11:01:34 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 06 11:01:35 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 06 11:01:35 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\42-Hijsankersysteem - ''Hijsmiddelen''; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\Tessa Plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\6. Bevestigen, hijsen en monteren\42-Hijsankersysteem - ''Hijsmiddelen''; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: 421321, NLRSnl_0-.21_GM_WPB_4213-MSH-L Hijslus-Fixing loop 1260_Mavotrans_R19:421321_M20:368359
In: Level 0
Type - Description: Hijslus | Lifting Loop M20; Classification: 0-.21 (Default Classification); Material: Steel, High Grade
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - d_nom: M20; e (mm): 35 mm
Type - Fire Protection - Brandwerendheid | Fire resistance rating: Niet getest | Not rated
Type - Forces - 0 - 9° (kN): 20 mm; 10 - 30° (kN): 20 mm; 31 - 45° (kN): 18 mm; 46 - 90° (kN): 0 mm
Type - Identity Data - Artikelnummer | Article number: 421321; Beschrijving | Description: Hijslus | Lifting Loop M20; Certificaten | Certification: CE; Laatste versie | Last version: 06-10-2022; Leverancier | Supplier: Mavotrans; Model: LOD400; NL-SfB code: 0-.21; Opmerkingen | Comments: Geschikt voor rechtstandig hijsen en hijsen onder een hoek tot 45° | Suitable for upright lifting and lifting at an angle up to 45°; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: D. Blokland; Type Comments: M30 en M36 op aanvraag leverbaar | M30 and M36 available on request; Type Name: 421321_M20; URL: https://mavotrans.nl/msh-l-hijslus-1260.html; Verpakkingshoeveelheid | Sales packaging: Verpakt per stuk | Sold per piece
Type - Materials and Finishes - Materiaal | Material: Roestvrij staal | Stainless steel
Type - Other - Category: Generic Models; Diameter: 20 mm; e: 35 mm; Family Name: NLRSnl_0-.21_GM_WPB_4213-MSH-L Hijslus-Fixing loop 1260_Mavotrans_R19; Radius: 0 mm
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_ProvisionForVoid - Diameter: 20 mm
Material: Steel, High Grade, Stainless Steel AISI 304
Pset_BuildingElementProxyCommon - Reference: NLRSnl_0-.21_GM_WPB_4213-MSH-L Hijslus-Fixing loop 1260_Mavotrans_R19:421321_M20; sets with these values: 2
Constraints - Level: Level: Level 0; Offset: 0 mm; Work Plane: Level : Level 0
Dimensions - Area: 0.0363086 m2; Volume: 0.00033145 m3
Other - Family: NLRSnl_0-.21_GM_WPB_4213-MSH-L Hijslus-Fixing loop 1260_Mavotrans_R19: 421321_M20; Family and Type: NLRSnl_0-.21_GM_WPB_4213-MSH-L Hijslus-Fixing loop 1260_Mavotrans_R19: 421321_M20; Schedule Level: Level: Level 0; Type: NLRSnl_0-.21_GM_WPB_4213-MSH-L Hijslus-Fixing loop 1260_Mavotrans_R19: 421321_M20; Type Id: NLRSnl_0-.21_GM_WPB_4213-MSH-L Hijslus-Fixing loop 1260_Mavotrans_R19: 421321_M20
Phasing - Phase Created: New Construction
